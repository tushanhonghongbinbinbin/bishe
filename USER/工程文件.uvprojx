# Keil uVision project 工程文件.uvprojx, settings and files
target poject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYSTEM;..\HARDWARE\hardware;..\HARDWARE\OLED_IIC;..\HARDWARE\MAX30100;..\HARDWARE\ADC;..\HARDWARE\MPU6050;..\HARDWARE\SIM900A;..\MQTT
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/scr/: led.c beep.c key.c timer.c GPS.c distance.c ds18b20.c
    ../HARDWARE/hardware/: HardWare.c
    ../HARDWARE/ADC/: adc.c mq.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../HARDWARE/scr/: stm32f10x_it.c
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart1.c usart.c
    ../HARDWARE/SIM900A/: sim800c.c
  group OLED
    ../HARDWARE/OLED_IIC/: oled_show.c oled.c
  group MPU6050
    ../HARDWARE/MPU6050/: MPU6050.c MyI2C.c
  group MQTT
    ../MQTT/: nbiot.c
  group MAX30102
    ../HARDWARE/MAX30100/: MAX30100.c MAX30100_BeatDetector.c MAX30100_Filters.c MAX30100_PulseOximeter.c MAX30100_SpO2Calculator.c
    ../HARDWARE/scr/: myiic.c
